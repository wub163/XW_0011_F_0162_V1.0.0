# IAR project XW_0011_F_V1.0.0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F0163D7PV MindMotion MM32F0163D7PV
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\MM32F0160_Device\CMSIS\IAR_CORE; ..\MM32F0160_Device\MM32F0160\HAL_lib\inc; ..\MM32F0160_Device\MM32F0160\Source\IAR_StartAsm; ..\MM32F0160_Device\MM32F0160\Include; ..\APP; ..\USER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART_DMA_Interrupt.srec
  ILINK.IlinkOutputFile: UART_DMA_Interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: app_comm.h app_uart.c app_uart.h
  group DOC
    ../: XW0011分控板资源分配.txt
  group HAL_LIB
    ../MM32F0160_Device/MM32F0160/HAL_lib/src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_hwdiv.c hal_i2c.c hal_i3c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_usb.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../MM32F0160_Device/MM32F0160/Source/IAR_StartAsm/: startup_mm32f0160_iar.s
    ../MM32F0160_Device/MM32F0160/Source/: system_mm32f0160.c
  group USER
    ../USER/: app.c app.h app_config.h application.h main.c main.h mm32f0160_it.c mm32f0160_it.h platform.c platform.h
