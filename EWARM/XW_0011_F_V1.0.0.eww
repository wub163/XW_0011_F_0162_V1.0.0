<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\XW_0011_F_V1.0.0.ewp</path>
    </project>
    <batchBuild />
</workspace>
